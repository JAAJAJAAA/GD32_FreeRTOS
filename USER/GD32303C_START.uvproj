# Keil uVision project GD32303C_START.uvproj, settings and files
target GD32303C_START (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303CG GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x080FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: GD32303CG_START +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\..\Utilities;..\CMSIS;..\USER;..\CMSIS\GD\GD32F3x0\Include;..\LIB\Include;..\CMSIS\STR;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS;..\APP\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c usart.c UserFlag.c
    ../LIB/Source/: gd32f30x_it.c systick.c
  group CMSIS
    ../CMSIS/: core_cm4.h
    ../CMSIS/GD/GD32F3x0/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../LIB/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group GD32F30x_START
    ../CMSIS/STR/: gd32f303c_start.c
  group Startup
    ../CMSIS/STR/: startup_gd32f30x_hd.s
  group FreeRTOS_Port
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS_Src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group APP
    ../APP/src/: GPIO.c Key.c ADC.c i2c.c PID.c FOC.c MotorTask.c MT6815.c Math.c StoreTask.c PWM.c
